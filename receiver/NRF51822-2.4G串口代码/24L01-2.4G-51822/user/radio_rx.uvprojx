# Keil uVision project radio_rx.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.0.3
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: radio_rx +hex
  c flags: Optim=1
  c misc: --c99
  c include: ..\project_nrf51\Basic\Include_H;..\project_nrf51\Basic\startup;..\project_nrf51\Basic\Include_C\nrf_delay;..\project_nrf51\Peripherals\boards;..\project_nrf51\Peripherals\radio_config;..\user;..\out;..\..\..\NRF51822-BLE串口代码\BLE_UART_Fly\Include\gcc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Start
    ../project_nrf51/Basic/startup/: arm_startup_nrf51.s project_nrf51822.c system_nrf51.c
  group User
    ../project_nrf51/Basic/Include_C/nrf_delay/: nrf_delay.c
    ./: led.c pm.c radio_rx.c time.c
  group HAL
    ../project_nrf51/Basic/Include_C/: nrf_gpio.c
    ../project_nrf51/Basic/Include_C/nrf_radio/: radio_config.c
    ../project_nrf51/Basic/Include_C/simple_uart/: simple_uart.c
    ./: nrf_adc.c
  group Peripheral
    ../project_nrf51/Peripherals/boards/: pca10001.h
